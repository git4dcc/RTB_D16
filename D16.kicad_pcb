# Repository git4dcc/RTB_D16

File README.md:

# RTB_D16

My Homebrew [D16](https://rtb4dcc.de/hardware/decoder/d16/) decoder is a single sided mobile decoder with NEM-651 connector. The decoder is designed to integrate into the [RTB](https://rtb4dcc.de/concept/) digital control infrastructure.

<details>
<summary>See also</summary>

- [RTB_D12 - custom](/../../../../git4dcc/RTB_D12) (Fleischmann V100)
- [RTB_D13 - custom](/../../../../git4dcc/RTB_D13) (Minitrix coach)
- [RTB_D15 - custom](/../../../../git4dcc/RTB_D15) (Minitrix V160)
- [RTB_D20 - NEM651](/../../../../git4dcc/RTB_D20)
- [RTB_D21 - Next18](/../../../../git4dcc/RTB_D21)
- [RTB_D22 - Plux16](/../../../../git4dcc/RTB_D22)
- [RTB_D23 - NEM652](/../../../../git4dcc/RTB_D23)

</details>

<details>
<summary>User Guides</summary>

- User Guide - DE
- [User Guide - EN](https://rtb4dcc.de/rtb_decoder_reference_en/)

</details>

<br>

The decoder has the following features,
- **NEM-651** connector
- **DCC**
  - DCC-A automatic logon
  - DCC-R protocol extension
  - Service Mode Programming
- **Railcom**
  - Channel 1/2
  - POM, xPOM
  - DYN: Speed, QoS, Track-voltage, Motor-current, AUX-current, Temp, Distance travelled
- Single sided
- Dimension: 17 x 11 mm
- 7-20V track voltage
- heartbeat LED
- adjustable max motor current (default 300mA)
- adjustable max AUX current (default 500mA)
- over temp protection
- Function output: LV/LR (dimmable, 1.4kHz) open drain
- Function output: AUX1/AUX2/AUX3 logic level (3.3V)
- optional external buffer capacitor (max. 1500uF)
- <10mA idle power consumption
- Firmware update over main tracks via DCC-R protocol

# Hardware
The current PCB layout uses SMD footprints with 0.5mm pitch and mainly 0402 parts. Reflow soldering is recommended, handsoldering will be difficult.

## PCB
- 6-layer PCB, FR4, 17 x 11 x 0.8mm (single sided)
- CPU: AVR64DA32
- Motor bridge: DRV8231
- Connector: NEM-651

## Kicad
[Schematic](doc/D16_schematic.pdf) | [Layout](doc/D16_layout.pdf) | [Gerber](gerber)

<details>
<summary>Dependency</summary>
<br>

:yellow_circle: Requires my Kicad project library [RTB_SamacSys](https://github.com/git4dcc/RTB_SamacSys) in the same directory tree.

</details>

## Firmware
Filename structure: { **pcb** }{ **code** }{ **version** }.hex

Example: **D16F0001**.hex

|   | Description |
| --- | --- |
| **pcb** | Name of matching hardware (**D16**) |
| **code** | Type of code contained (**R**=rom, **B**=bootloader, **F**=flash, **U**=bld update, **P**=UPDI factory code) |
| **version** | Release version (**####**) |

[Firmware files](firmware)

# Images
| top | bottom |
| --- | --- |
|  |  |

# YouTube
Some YouTubes to see the D16 decoder in action.<br><br>

This project is intended for hobby use only and is distributed in accordance with the Apache License 2.0 agreement.

## KiCad design D16.kicad_pcb

Board: 6 copper layers, 17.0 x 10.9 mm, 43 parts (4 on the bottom side), 42 nets.

Parts:
C1, C3, C13: 22u/4V; C_0402_1005Metric
C2: 100u/4V; C_0805_2012Metric
C4: 1u/35V; C_0603_1608Metric
C6: 1u; C_0402_1005Metric
C7: 22u/25V; C_0805_2012Metric
D1: LED; LED_0402_1005Metric
D3: BAS3007ARPPE6327HTSA1; BF998215
IC1: DRV8231ADSGR; SON50P200X200X80-9N
IC2: NCP730BMT330TBG; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias
J1: Service IF; PinHeader_2x04_P1.27mm_Vertical
J2: NEM651; PinHeader_1x08_P1.27mm_Horizontal
Q1: BC857BDW1; SOT-666
Q2: BC847BDW1; SOT-666
Q3: SSM6N55NU; CSD87502Q2
R1, R2: 3.3k; R_0402_1005Metric
R3: 22; R_0402_1005Metric
R4, R5, R6: 2.2k; R_0402_1005Metric
R7, R8, R10, R12: 33k; R_0402_1005Metric
R9, R22: 2.2; R_0402_1005Metric
R11, R13, R15, R18, R19, R20: 10k; R_0402_1005Metric
R14, R16: dummy; R_0402_1005Metric
R17, R34, R35: 220k; R_0402_1005Metric
R21: 1k; R_0402_1005Metric
R36, R37: 9.1k; R_0402_1005Metric
U1: AVR-64DA32; VQFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm

Connections:
+3V3: C1.2, C2.1, C3.1, C13.2, IC2.1, J1.4, Q1.1, R3.1, U1.18, U1.28
AUX1: R6.1, U1.13
AUX2: R4.1, U1.14
AUX3: R5.1, U1.15
DCC-a: D3.3, J2.5, Q2.3, R7.1, R19.2, R34.1
DCC-b: D3.2, J2.4, Q2.6, R8.1, R20.2, R35.1
F0f: Q3.5, U1.1
F0r: Q3.2, U1.32
GND: C1.1, C2.2, C3.2, C4.2, C6.2, C7.2, C13.1, D1.1, D3.1, IC1.7, IC1.9, IC2.3, IC2.7, J1.6, J2.8, Q2.4, R2.1, R9.1, R11.1, R13.1, R19.1, R20.1, R22.1, R36.2, R37.2, U1.19, U1.29, U1.33
IFL: R21.2, U1.12
ISENS: C6.1, R17.2, U1.21
LED.hbt: R1.1, U1.9
Lf: J2.7, Q3.3, Q3.D2
Lr: J2.6, Q3.6, Q3.D1
M1: IC1.8, J2.3, R12.2
M2: IC1.6, J2.2, R10.2
unnamed: D1.2, R1.2, R16.2
unnamed: IC1.1, R2.2, R17.1
unnamed: Q1.2, Q1.4, R3.2
unnamed: Q1.3, Q2.1, Q2.2, R18.2
unnamed: Q1.5, Q1.6, R15.2
unnamed: Q2.5, R18.1
unnamed: Q3.1, Q3.4, R9.2, R21.1, R22.2
unnamed: R7.2, U1.8
unnamed: R8.2, U1.23
unnamed: R6.2, R14.1
unnamed: R4.2, R14.2
unnamed: R5.2, R16.1
PWM1: IC1.2, U1.2
PWM2: IC1.3, U1.3
RCM.tx: R15.1, U1.24
UDCC-a: R34.2, R36.1, U1.10
UDCC-b: R35.2, R37.1, U1.20
UPDI: J1.3, U1.27
V24.cts: J1.2, U1.26
V24.rts: J1.1, U1.25
V24.rx: J1.8, U1.31
V24.tx: J1.5, U1.30
VHBR: C4.1, C7.1, D3.4, IC1.5, IC2.6, J2.1
Vref: IC1.4, U1.16
uSENS1: R12.1, R13.2, U1.11
uSENS2: R10.1, R11.2, U1.17

## Commit log

2024-09-29 Changed H-Bridge, added hardware PWM
2024-10-04 Added local images
2024-10-29 initial
2024-11-15 mod: firmware
2024-11-16 mod: documentation
2025-03-22 add: decoder lock
2025-08-05 mod: led automation
2026-02-20 git mirror test

Notices in the files:
D16.kicad_pcb:
Licensed under the Apache License, Version 2
